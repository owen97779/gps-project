# Repository owen97779/gps-project

File README.md:

# gps-project
Repository of the GPS website frontend and backend

For Website_GPS in terminal run,

pip install -r requirements.txt

to get all of the required installs.

## KiCad design KiCad/GPS Hardware/GPS Prototype 2 - ESP32/GPS Hardware.kicad_pcb

Parts:
C13, C14, C25: 4u7; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C18: 10n; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C19, C22, C23, C31: 0u1; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C20: 56p; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C21: 15p; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C27, C28, C29, C30: 47p; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D2: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D3: LED; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
J3: Conn_Coaxial; RFSOLUTIONS_CON-SMA-EDGE-S
J6: SIM8065-6-1-14-01-A_REVA1; GCT_SIM8065-6-1-14-01-A_REVA1; PARTREV A1
Q1: BC847; SOT-23
Q2: 2N7002; SOT-23
R15: 1k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R16: 100k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R17: 10k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R18: 47k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R19: 820; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
U7: 74AVC2T245GU-Q100X; QFN40P140X180X50-10N
U8: SARA-U201; ublox_SARA-G3_LGA-96
U10: ublox_SAM-M8Q

Connections:
+1V8: C22.1, U7.6, U8.4 (V_INT); also elsewhere on the board
CLK: C28.1, J6.C3, U8.38 (SIM_CLK)
CTS_Cellular: U8.11 (CTS); also elsewhere on the board
EXTINT: U7.9, U10.19 (EXTINT); also elsewhere on the board
GND: C13.2, C14.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C25.2, C27.2, C28.2, C29.2, C30.2, C31.2, D3.1 (K), J3.2 (Ext), J6.C5, J6.G1, J6.G2, J6.G3, J6.G4, Q1.2 (E), Q2.2 (S), R18.2, U7.1, U7.2, U7.3, U8.1 (GND), U8.3 (GND), U8.5 (GND), U8.9 (DTR), U8.14 (GND), U8.20 (GND), U8.21 (GND), U8.22 (GND), U8.30 (GND), U8.32 (GND), U8.43 (GND), U8.50 (GND), U8.54 (GND), U8.55 (GND), U8.57 (GND), U8.58 (GND), U8.59 (GND), U8.60 (GND), U8.61 (GND), U8.63 (GND), U8.64 (GND), U8.65 (GND), U8.66 (GND), U8.67 (GND), U8.68 (GND), U8.69 (GND), U8.70 (GND), U8.71 (GND), U8.72 (GND), U8.73 (GND), U8.74 (GND), U8.75 (GND), U8.76 (GND), U8.77 (GND), U8.78 (GND), U8.79 (GND), U8.80 (GND), U8.81 (GND), U8.82 (GND), U8.83 (GND), U8.84 (GND), U8.85 (GND), U8.86 (GND), U8.87 (GND), U8.88 (GND), U8.89 (GND), U8.90 (GND), U8.91 (GND), U8.92 (GND), U8.93 (GND), U8.94 (GND), U8.95 (GND), U8.96 (GND)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; also elsewhere on the board
GPIO3: U7.5, U8.24 (GPIO3)
GPIO4: U7.4, U8.25 (GPIO4)
IO: C29.1, J6.C7, U8.39 (SIM_IO)
unnamed: D2.1 (K), Q1.3 (C)
unnamed: D2.2 (A), R19.2
unnamed: D3.2 (A), R15.2
unnamed: J3.1 (In), U8.56 (ANT)
unnamed: Q1.1 (B), R17.2, R18.1
unnamed: Q2.3 (D), U8.18 (~RESET)
unnamed: R15.1, U10.7 (TIMEPULSE)
unnamed: R17.1, U8.16 (GPIO1)
PWR_Cellular: R16.2, U8.15 (PWR_ON); also elsewhere on the board
RESET_Cellular: Q2.1 (G); also elsewhere on the board
RST: C27.1, J6.C2, U8.40 (SIM_RST)
RTS_Cellular: U8.10 (RTS); also elsewhere on the board
RX_Cellular: U8.13 (RXD); also elsewhere on the board
SYS: C18.1, C19.1, C20.1, C21.1, R19.1, U8.51 (VCC), U8.52 (VCC), U8.53 (VCC); also elsewhere on the board
TX_Cellular: U8.12 (TXD); also elsewhere on the board
TX_GPS: U7.8, U10.13 (TXD); also elsewhere on the board
VSIM: C30.1, C31.1, J6.C1, U8.41 (VSIM)

Notes on the sheet:
GPIO2 Pin has a 1ma output, no need for a resistor

Schematic: MCU.sch

Parts:
C10, C11, C16, C17: 0u1; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
J2: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical_SMD_Pin1Left
J4: Conn_01x05_Male; PinHeader_1x05_P2.54mm_Vertical_SMD_Pin1Left
J7: Conn_01x08_Male; PinHeader_1x08_P2.54mm_Vertical_SMD_Pin1Left
R12, R13: 10k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R14: 100k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
S1, S2: TS04-66-55-BK-160-SMT; SW_TS04-66-55-BK-160-SMT; PARTREV 1.0
U1: ESP32-WROOM-32D; ESP32-WROOM-32
U6: SN74AVC4T774PW; SOP65P640X120-16N

Connections:
+1V8: C16.1, U6.15; also elsewhere on the board
/MCU Schematic/IO2: J4.3, U1.24 (IO2)
/MCU Schematic/IO4: J4.1, U1.26 (IO4)
/MCU Schematic/IO5: J4.2, U1.29 (IO5)
/MCU Schematic/IO12: J7.1, U1.14 (IO12)
/MCU Schematic/IO13: J4.5, U1.16 (IO13)
/MCU Schematic/IO14: J7.2, U1.13 (IO14)
/MCU Schematic/IO15: J4.4, U1.23 (IO15)
/MCU Schematic/IO32: J7.5, U1.8 (IO32)
/MCU Schematic/IO33: J7.4, U1.9 (IO33)
/MCU Schematic/IO35: J7.6, U1.7 (IO35)
/MCU Schematic/SENS_VN: J7.7, U1.5 (SENSOR_VN)
/MCU Schematic/SENS_VP: J7.8, U1.4 (SENSOR_VP)
CTS: U1.31 (IO19), U6.3
CTS_Cellular: U6.13; also elsewhere on the board
EXTINT: U1.12 (IO27); also elsewhere on the board
GND: C10.2, C11.2, C16.2, C17.2, J2.2, R14.2, S1.2, S1.4, S2.1, S2.3, U1.1 (GND), U1.15 (GND), U1.38 (GND), U1.39 (GND), U6.1, U6.7, U6.9, U6.10; also elsewhere on the board
INT_Power: U1.6 (IO34); also elsewhere on the board
unnamed: C10.1, R12.2, S1.3, U1.3 (EN)
unnamed: R13.2, S2.4, U1.25 (IO0)
PWR_Cellular: U1.37 (IO23); also elsewhere on the board
RESET_Cellular: R14.1, U1.10 (IO25); also elsewhere on the board
RTS: U1.30 (IO18), U6.4
RTS_Cellular: U6.14; also elsewhere on the board
RX: U1.28 (IO17), U6.5
RX_Cellular: U6.11; also elsewhere on the board
RX_MCU: J2.3, U1.34 (RXD0/IO3)
SCL_Power: U1.36 (IO22); also elsewhere on the board
SDA_Power: U1.33 (IO21); also elsewhere on the board
TX: U1.27 (IO16), U6.6
TX_Cellular: U6.12; also elsewhere on the board
TX_GPS: U1.11 (IO26); also elsewhere on the board
TX_MCU: J2.4, U1.35 (TXD0/IO1)

Schematic: Power.sch

Parts:
C1: 1u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C2, C6: 22u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C3: 47n; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C4: 4u7; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C5, C8: 10u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C7: 220u; CP_EIA-3528-12_Kemet-T_Pad1.50x2.35mm_HandSolder
C9: 0u1; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C12: 100u; CP_EIA-6032-15_Kemet-U_Pad2.25x2.35mm_HandSolder
D1: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D7: SP712-02HTG; SOT95P237X115-3N; Mouser Part Number 576-SP712-02HTG
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J5: B2B-XH-A(LF)(SN); JST_B2B-XH-A(LF)(SN); PARTREV 1.0
L1: 2u2; IND_SRP0312-2R2K
R1, R2: 5k1; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R3, R4, R5: 4k7; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R6, R7, R9: 10k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R8: 250; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R10: 5k23; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R11: 32k; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
TH1: Thermistor_NTC 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U2: MIC5209-4.2YS-TR; SOT-223
U3: BQ24295; QFN50P400X400X100-25N

Connections:
D+: D7.1, J1.A6 (D+), J1.B6 (D+), U3.2
D-: D7.2, J1.A7 (D-), J1.B7 (D-), U3.3
GND: C1.2, C2.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C12.2, D7.3, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J5.2, R1.1, R2.1, R6.2, R7.1, R11.2, TH1.2, U2.2, U2.4, U3.17, U3.18, U3.25; also elsewhere on the board
INT_Power: R5.1, U3.7; also elsewhere on the board
unnamed: C2.1, U3.23
unnamed: C3.1, U3.21
unnamed: C3.2, L1.1, U3.19, U3.20
unnamed: C4.1, R10.1, U3.22
unnamed: C5.1, J5.1, U3.13, U3.14
unnamed: D1.1 (K), R8.1
unnamed: J1.A5 (CC1), R1.2
unnamed: J1.B5 (CC2), R2.2
unnamed: R6.1, U3.9
unnamed: R7.2, U3.10
unnamed: R8.2, U3.4
unnamed: R9.1, U3.8
unnamed: R10.2, R11.1, TH1.1, U3.11
SCL_Power: R3.1, U3.5; also elsewhere on the board
SDA_Power: R4.2, U3.6; also elsewhere on the board
SYS: C6.1, C7.1, C8.1, C9.1, D1.2 (A), L1.2, R9.2, U2.1, U3.15, U3.16; also elsewhere on the board
VBUS: C1.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U3.1, U3.24

Notes on the sheet:
Check if switch is required
Different capacitor values for low impedance at a range of frequencies

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
Board: 4 copper layers, 71 parts (14 on the bottom side), 65 nets, no tracks yet.

## Commit log

2021-07-15 Fixed the directories
2021-07-15 New files after running django for the first time
2021-07-15 Added some informative text on the readme
2021-07-15 Added another file using pycharm + git
2021-07-15 Added some text using pyCharm
2021-07-15 hahaha
2021-07-15 GEeeps
2021-07-15 Home page html
2021-07-15 home page html (home.html) hello page html (index.html)
    Functions in views.py (home, index)
    functions redirect to appropriate urls
    urls.py (imports added)
    paths added for home(homepage) and index(\hello)
2021-07-15 misc stuff
2021-07-16 Potential links to the homepage, just an idea
2021-07-17 new user directory for registeration and later implementing login.
    registeration system needs email, and more testing/style but works into the database.
    added openstreetmap on the home page.
2021-07-19 Added email into registeration linked login/register
    login/register are visible and link
2021-07-26 Removed Profile pictures Commented out
    Profile can be updated
    Username, Email
    Formatted the website
    Login, Register, Home
    Added logo and name
    Both have anchored href
2021-07-26 Home Page map zoom size
2021-07-26 Updated with a map in "http://127.0.0.1:8000/index"
2021-08-02 uhhhh got the height to work on index.html
2021-08-10 map in "http://127.0.0.1:8000/index" has markers
    Database migration onto MySQL complete.
2021-08-18 Added KiCad project files
2021-08-18 in progress
2021-08-19 Added new schematics that aren't done yet
2021-08-19 Fixed the home page using OpenLayers
    Previous commit was a mess I deeeeeeply apologies for my HUGE mistake I don't know how I'll ever make come back from this humiliating defeat! ;(((
2021-08-19 small update to the previous one
2021-08-19 small update to the previous one again
2021-08-19 Create home
2021-08-20 semi progress error
2021-08-20 Got lines Got data from da base :O ;O
    Next step:
    Pretty up the line,
    Make an app to collect test GPS data.
    The pain to get from the database to the lines on screen took hours off my sleep, help.
    FINALLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLLY
2021-08-21 Finished adding components, need to add values
2021-08-22 Update, 21st August
2021-08-22 Added footprints to most components
2021-08-22 Added all footprints
    Hopefully they are correct :)
2021-08-22 Started pcb layout
2021-08-24 Update for PC
2021-08-25 Update for PC again
2021-08-26 Update to laptop
2021-08-28 Update once again
2021-08-29 Update (again :+1: )
2021-08-29 Update once more
2021-08-30 Update dude
2021-08-31 Update to PC
2021-08-31 Reorganize
    Reorganize
2021-08-31 Location from phone to MySQL
    Location from phone to MySQL
2021-08-31 add this too
2021-08-31 More Stuff
2021-08-31 Update PC
2021-09-01 Phone GPS
    Phone GPS data collect
2021-09-03 Update to laptop
    Yay
2021-09-04 Update layout once again
    1. SIG/POWER (3.8v)
    2. GROUND
    3. SIG/POWER (3.3v)
    4. GROUND
2021-09-04 Update again
    Put some copper pour down as a test.
2021-09-05 Test
    Commit
2021-09-06 Update for today
    Just added a couple sim power lines to see how it will affect the 3v3 plane
2021-09-11 Update to laptop
    Hopefully it works
2021-09-16 Update to Laptop
    Properly
2021-09-21 Update to laptop
    You need to finish gnd via placement
2021-09-24 Update to PC Remember to double-check pads
2021-09-26 Update from laptop
2021-10-13 Update from university
2021-10-15 Updated silkscreen
2021-10-15 Finishing touches
2021-10-18 Changed via placement and all that jazz
2021-10-18 Updated the sim choice to a push-push type, and generated the final gerber files
2021-10-26 Changed resistor values for LEDs
2022-02-23 Created a second prototype, continue to finish it
2022-02-25 Big Progress Commit
    I don't know what I did because there's so much I'm adding.
    I think the app has progressed a lot from the last commit.
    -Fixed Password Reset Spacing
    -Added UI to reset password
    -Added Pass
    -App read and write needs to be fixed
2022-02-25 IP Correction
    The app now receives and sents data using this ip on campus.
2022-03-03 Delete KiCad/GPS Hardware directory
    Cleanup
2022-03-03 Delete .idea directory
    Cleanup
2022-03-03 Delete hello directory
    Cleanup
2022-03-03 Delete users directory
    Cleanup
2022-03-03 Delete website directory
    Cleanup
2022-03-03 Delete README.md
    Cleanup
2022-03-03 Delete manage.py
    Cleanup
2022-03-03 Delete test.txt
    Cleanup
2022-03-08 Connected all the PCB connections and 20h distance
2022-06-05 Update
    5th June 2022, change the LDO and other components next time.
2022-06-08 update
    update
2022-06-08 Alvin house Mo update
    Have your kicad update
2022-06-09 Some extra save stuff
    Some extra save stuff
2022-06-09 Firebase start setup
    URL: https://we-jam-ca4be.web.app/
    Website deployed: firebase deploy --only hosting
    Emulators: firebase emulators:start
    Emulator local: http://localhost:5000/
2022-06-12 Unnessasary commit with firebase ;(
2022-06-17 Firebase changes and organizing the files
2022-06-20 Cleaning
2022-06-22 ESP stuff learning
2022-06-22 Push to laptop
    Add traces etc.
2022-06-25 Added User addition to firebase
    Problem: Everytime there's a new user the database is overwritten
2022-06-26 Moderate change
2022-06-26 add requirements.txt file
2022-06-26 add gitignore line
2022-06-27 Update to Uni computers
    Finish esp32 connections.
2022-06-27 Update from Uni
2022-07-10 Update to Laptop
    Still a lot more to go
2022-07-29 Connect ESP 32 to Arduino
    communicate via binary
2022-08-07 Hardware testing
2022-08-07 quick update
2022-08-07 reconnect
2022-08-07 Secret Disappearrrrrrrrrr
    shhhhhhhhhhhhhiii
2022-08-07 more secret
2022-10-08 Simplification of repo
2022-10-08 Cleansed the main branch
